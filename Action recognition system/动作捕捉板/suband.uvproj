# Keil uVision project suband.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15W204S STC
  cpu: IRAM(0-0xFF) IROM(0-0x0FF8) CLOCK(35000000) MODP2
  output: suband +hex
  c flags: Optimize=8 SizeSpeed=1
  group code
    ./User/: main.c Bluetooth.c MPU9250.c
